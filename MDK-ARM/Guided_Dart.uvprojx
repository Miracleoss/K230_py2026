# Keil uVision project Guided_Dart.uvprojx, settings and files
target Guided_Dart (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Guided_Dart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User;../User/Algorithm;../User/App;../User/Config;../User/Device;../User/Driver;../User/Utils;../User/Driver/Inc;../User/Device/Inc;../User/App/Inc;../User/Algorithm/Inc;../User/Utils/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Algorithm
    ../User/Algorithm/Src/: alg_alloc.cpp alg_attitude.cpp alg_control.cpp alg_png.cpp
    ../User/Algorithm/Inc/: alg_alloc.h alg_attitude.h alg_control.h alg_png.h
  group App
    ../User/App/Src/: app_flight.cpp app_task.cpp
    ../User/App/Inc/: app_flight.h app_task.h
  group Config
    ../User/Config/: Config.h fc_param.h hw_config.h pin_def.h
  group Device
    ../User/Device/Src/: dev_bmi088.cpp dev_k230.cpp dev_servo.cpp dev_motor.cpp dev_temp_ctrl.cpp
    ../User/Device/Inc/: dev_bmi088.h dev_k230.h dev_motor.h dev_servo.h dev_temp_ctrl.h
  group Driver
    ../User/Driver/Src/: drv_delay.cpp drv_gpio.cpp drv_spi.cpp drv_tim.cpp drv_uart.cpp
    ../User/Driver/Inc/: drv_delay.h drv_gpio.h drv_tim.h drv_uart.h drv_spi.h
  group Utils
    ../User/Utils/Src/: util_filter.cpp util_math.cpp
    ../User/Utils/Inc/: util_filter.h util_math.h vofa.h
software components: CMSIS:CORE 6.1.0
