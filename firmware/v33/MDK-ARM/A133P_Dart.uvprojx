# Keil uVision project A133P_Dart.uvprojx, settings and files
target A133P_Dart (6220000::V6.22::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: A133P_Dart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../User;../User/Task;../User/Driver;../User/Device;../User/Algorithm;../User/Application;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/Common
    ../User/Common/: common_types.h coordinate_convention.h imu_data.h attitude_state.h control_command.h surface_command.h system_status.h host_overload_command.h dart_light_status.h
  group Application/User/Config
    ../User/Config/: board_hardware_config.h servo_config.h control_config.h servo_config.cpp dart_light_config.h
  group Application/User/Driver
    ../User/Driver/: drv_gpio_pin.h drv_gpio_pin.cpp drv_spi_bus.h drv_spi_bus.cpp drv_pwm_channel.h drv_pwm_channel.cpp drv_timebase.h drv_timebase.cpp drv_uart_dma.h drv_uart_dma.cpp drv_uart_half_duplex.h drv_uart_half_duplex.cpp
  group Application/User/Protocol
    ../User/Protocol/: host_serial_protocol.h host_serial_protocol.cpp dart_light_protocol.h dart_light_protocol.cpp
  group Application/User/Device
    ../User/Device/: dev_bmi088.h dev_bmi088.cpp dev_servo.h dev_servo.cpp dev_imu_heater.h dev_imu_heater.cpp dev_host_serial.h dev_host_serial.cpp dev_dart_light.h dev_dart_light.cpp dev_key_edge_counter.h dev_key_edge_counter.cpp
  group Application/User/Algorithm
    ../User/Algorithm/: alg_xtail_mixer.h alg_xtail_mixer.cpp alg_attitude_estimator.h alg_attitude_estimator.cpp alg_closed_loop_controller.h alg_closed_loop_controller.cpp
  group Application/User/Application
    ../User/Application/: app_dart_system.h app_dart_system.cpp
  group Application/User/Task
    ../User/Task/: task_bridge.h task_bridge.cpp
software components: CMSIS:CORE 6.1.0
